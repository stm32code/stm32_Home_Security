# Keil uVision project LCD.uvprojx, settings and files
target LCD (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\FWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\OLED;..\SYSTEM\usart;..\HARDWARE\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: system_stm32f10x.c main.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c
  group HARDWARE
    ../HARDWARE/BSP/: esp8266.c uc1701.c adc.c ds18b20.c
